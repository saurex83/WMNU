# IAR project unitest.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: \\vmware-host\Shared Folders\Projects\WMNU\IAR\SHARE_PRJ_SRC
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    src/: utest.c utest_suite.c utest_suite.h
  group share src
    ../SHARE_PRJ_SRC/: FChain.c FChain.h FItem.c FItem.h Frames.h LLC.c LLC.h MAC.c MAC.h NTMR.c NTMR.h nwdebuger.c nwdebuger.h RADIO.c RADIO.h sig_trace.h sig_trace_defs.h TIC.c TIC.h
  group test modules
    src/: utest_FChain.c utest_FItem.c utest_Frames.c utest_LLC.c utest_MAC.c utest_NTMR.c utest_TIC.c
