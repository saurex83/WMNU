# IAR project neocoregw.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\WMNU\IAR\SHARE_PRJ_SRC
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    src/: main.c
  group gateway
    src/: cmd_0x00.c cmd_0x01.c cmd_0x02.c cmd_0x03.c cmd_0x04.c cmd_0x05.c cmd_0x06.c cmd_0x07.c cmd_0x08.c cmd_0x09.c cmd_0x0A.c cmd_0x0B.c cmd_0x0C.c cmd_0x0D.c cmd_0x0E.c cmd_index_list.h cmd_parser.c cmd_parser.h uart_comm.c uart_comm.h
  group neocore
    ../SHARE_PRJ_SRC/: basic.h coder.c coder.h config.c config.h delays.c delays.h dma.c dma.h ethernet.c ethernet.h frame.c frame.h LLC.c LLC.h MAC.c MAC.h manager.c manager.h mem.c mem.h Net_frames.h NTMR.c NTMR.h nwdebuger.c nwdebuger.h RADIO.c RADIO.h Radio_defs.h rx_buff.c rx_buff.h sig_trace.h sig_trace_defs.h sync.c sync.h TIC.c TIC.h
