# IAR project transmiter.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\WMNU\IAR_new_arch\Stack_core_src
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group stack core
    ../STACK_CORE_SRC/: action_manager.c alarm_timer.c buffer.c coder.c cpu.c debug.c dma.c frame.c llc.c mac.c mem_slots.c model.c radio.c sync.c time_manager.c ustimer.c
    ../Stack_core_src/: action_manager.h alarm_timer.h buffer.h coder.h cpu.h debug.h dma.h frame.h global.h led.c led.h list.h llc.h mac.h macros.h mem_slots.h mem_utils.c mem_utils.h meta.h model.h model_import_struct.h modules_list.h radio.h radio_defs.h rtc.c rtc.h sync.h time_manager.h ustimer.h
  group transmiter
    ./: cmd_0x00.c cmd_0x01.c cmd_0x02.c cmd_0x03.c cmd_0x04.c cmd_0x05.c cmd_0x06.c cmd_0x07.c cmd_0x08.c cmd_0x09.c cmd_0x0A.c cmd_0x0B.c cmd_0x0C.c cmd_0x0D.c cmd_0x0E.c cmd_0x0F.c cmd_0x10.c cmd_index_list.h cmd_parser.c cmd_parser.h uart_comm.c uart_comm.h
