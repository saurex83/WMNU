# IAR project tests.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\WMNU\IAR_new_arch\Stack_core_src
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
    ../STACK_CORE_SRC/: NOTE.txt
  group stack core
    ../STACK_CORE_SRC/: action_manager.c alarm_timer.c cpu.c debug.c frame.c mem_utils.c mem_utils.h model.c rtc.c tempalte.txt time_manager.c ustimer.c ustimer.h
    ../Stack_core_src/: action_manager.h alarm_timer.h cpu.h debug.h frame.h global.h model.h model_import_struct.h modules_list.h rtc.h time_manager.h
  group unit tests
    ./: u_alarm_timer.c u_debug.c
