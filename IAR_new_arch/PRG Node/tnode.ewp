# IAR project tnode.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\WMNU\IAR_new_arch\Stack_core_src
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group stack core
    ../Stack_core_src/: action_manager.c alarm_timer.c buffer.c cpu.c dma.c dma.h frame.c led.c led.h list.h llc.h mac.c mac.h mem_slots.c mem_slots.h mem_utils.h model.c modules_list.h rtc.c
    ../STACK_CORE_SRC/: action_manager.h alarm_timer.h buffer.h coder.c coder.h cpu.h debug.c debug.h frame.h global.h llc.c macros.h mem_utils.c meta.h model.h model_import_struct.h radio.c radio.h radio_defs.h rtc.h sync.c sync.h time_manager.c time_manager.h ustimer.c ustimer.h
